# Keil uVision project test.uvprojx, settings and files
target memory (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 wLevel=2
  c define: USE_STDPEREPH_DRIVER,STM32F10X_MD
  c include: ..\usr;.\RTE;.\RTE\Device\STM32F103C8;..\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group usr
    ../usr/: main.cpp IAP.cpp IAP.h
  group lib
    ../lib/: FIFOBuffer.h Interrupt.cpp Interrupt.h Memory.cpp Memory.h USART.cpp USART.h TaskManager.cpp TaskManager.h GPIO.cpp
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
