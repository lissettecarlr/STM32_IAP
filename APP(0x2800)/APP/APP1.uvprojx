# Keil uVision project APP1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: APP1
  AfterMake: C:\Other\keil5\ARM\ARMCC\bin\fromelf.exe --bin -o E:\project\SMT32F1_PRO\pro_git\IAP\APP(0x2800)\APP\RTE\APP.bin E:\project\SMT32F1_PRO\pro_git\IAP\APP(0x2800)\APP\Objects\App1.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\APP;.\Lib
  memory RVCT4: ROM 0x8002800 size 0x1d800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group usr
    ./: main.cpp
  group Lib
    ./Lib/: FIFOBuffer.h GPIO.cpp GPIO.h Interrupt.cpp Interrupt.h TaskManager.cpp TaskManager.h USART.cpp USART.h
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
